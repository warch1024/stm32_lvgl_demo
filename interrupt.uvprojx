# Keil uVision project interrupt.uvprojx, settings and files
target LVGL (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: interrupt +hex
  AfterMake: fromelf --bin --output .\Objects\interrupt.bin .\Objects\interrupt.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE;.\RTE\Device\STM32F407ZE;.\hardware;.\tools;.\system;.\LCD\app;.\LCD\driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: main.c
  group hardware
    ./hardware/: key_interrupt.c key_interrupt.h led.c led.h mq_2.c mq_2.h timer.c timer.h beep.c beep.h motor.c motor.h uart.c uart.h CO2_sensor.c CO2_sensor.h DX_BT24.c DX_BT24.h esp8266.c esp8266.h RS485.c RS485.h ultra_sound.c ultra_sound.h temperature_humidity_sensor.c temperature_humidity_sensor.h Flash.c Flash.h soft_iic.c soft_iic.h eeprom.c eeprom.h oled_code_table.h oled_iic.c oled_iic.h SPI.c SPI.h spi_flash.c spi_flash.h RC522.c RC522.h SPI_LCD.c SPI_LCD.h SPI_LCD_code_table.h CAN.c CAN.h
  group tools
    ./tools/: tools.c tools.h esp8266_mqtt.c esp8266_mqtt.h radar.c radar.h rc522_app.c rc522_app.h
  group system
    ./system/: systick.c systick.h pwm.c pwm.h retarget.c retarget.h DFA_event_queue.c DFA_event_queue.h event_handlers.c event_handlers.h IWDG.c IWDG.h RTC.c RTC.h ADC.c ADC.h DMA.c
  group LCD/app
    ./LCD/app/: GUI.c GUI.h pic.h test.c test.h lcd_demo.c lcd_demo.h
  group LCD/driver
    ./LCD/driver/: touch.h touch.c myiic.h myiic.c lcd.h lcd.c FONT.H 24cxx.h 24cxx.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:FSMC 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
